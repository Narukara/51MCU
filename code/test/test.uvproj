# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\h
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../hc/: time.c uart.c LCD1602A.c
